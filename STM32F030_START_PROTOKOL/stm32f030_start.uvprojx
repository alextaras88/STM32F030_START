# Keil uVision project stm32f030_start.uvprojx, settings and files
target stm32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f030_start +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\STM32F030_START;.\CMSIS;.\CMSIS\inc;.\CODE;.\CODE\inc;.\Startup;.\SSD1306
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ./CMSIS/src/: system_stm32f0xx.c
  group CODE
    ./CODE/src/: main.c system_init.c delay.c spi.c i2c.c pwm.c exti.c adc.c pi_control.c lcd_i2c.c lcd1602.c eeprom.c usart.c ads1220.c ads131e08.c weight.c ad7730.c printer.c OWEN_485.c
    ./SSD1306/: ssd1306.c ssd1306_fonts.c
  group Startup
    ./Startup/: startup_stm32f030x6.s
